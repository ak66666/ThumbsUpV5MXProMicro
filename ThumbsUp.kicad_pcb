# Repository ak66666/ThumbsUpV5MXProMicro

File README.md:

# ThumbsUp! v5 ProMicro MX/Alps

Multilevel 58 Key Ergonomic Keyboard.
3-key Thumb Cluster.

ProMicro pin-compatible MCUs: Atmega32U4, RP2040, and nice!nano (oritinal and clones) with battery for the bluetooth connectivity.

The board uses either Cherry MX-compatible switches in hot-swap sockets, or ALPS/Matias soldered-in switches.

Board needs 3D printed switch plates: https://github.com/ak66666/ThubmsUpSwitchPlates

Other pictures in Photos folder.

# Firmware

Please refer to this article:
https://thumbsupkeyboards.blogspot.com/2024/02/source-files-and-default-firmware.html

## KiCad design ThumbsUp.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58: D_Small; D_SOD-123
H1: MountingHole_Pad; MountingHole_6mm_Pad_Via
H2: MountingHole_Pad; MountingHole_8.4mm_M8_Pad_Via
J19: 52559-1233; 525591233; Mouser Part Number 538-52559-1233
J32: Battery; PinHeader_1x02_P2.54mm_Vertical
JF3, JF5, JF20, JF21, JF22, JF23, JF28, JF29, JF30, JF31, JF33, JF43, JF45: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
JF9, JF11, JF13, JF17: Raiser_Female; PinSocket_1x04_P2.54mm_Vertical
JM3, JM20, JM21, JM22, JM23, JM28, JM29, JM30, JM31, JM33, JM43, JM45: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
JM5: Male; PinHeader_1x04_P2.54mm_Vertical
JM9, JM11, JM13, JM17: Raiser_Male; PinHeader_1x04_P2.54mm_Vertical
MX1: SwESC; MX-1U-NoLED_HotSwap
MX2: SwTAB; MX-1U-NoLED_HotSwap
MX3: SwLCTL; MX-1U-NoLED_HotSwap
MX4: SwQ; MX-1U-NoLED_HotSwap
MX5: SwA; MX-1U-NoLED_HotSwap
MX6: SwZ; MX-1U-NoLED_HotSwap
MX7: SwW; MX-1U-NoLED_HotSwap
MX8: SwS; MX-1U-NoLED_HotSwap
MX9: SwX; MX-1U-NoLED_HotSwap
MX10: SwLWIN; MX-1U-NoLED_HotSwap
MX11: SwE; MX-1U-NoLED_HotSwap
MX12: SwD; MX-1U-NoLED_HotSwap
MX13: SwC; MX-1U-NoLED_HotSwap
MX14: SwLALT; MX-1U-NoLED_HotSwap
MX15: SwR; MX-1U-NoLED_HotSwap
MX16: SwF; MX-1U-NoLED_HotSwap
MX17: SwV; MX-1U-NoLED_HotSwap
MX18: SwLMOD; MX-1U-NoLED_HotSwap
MX19: SwT; MX-1U-NoLED_HotSwap
MX20: SwG; MX-1U-NoLED_HotSwap
MX21: SwB; MX-1U-NoLED_HotSwap
MX22: SwLSHFT; MX-1U-NoLED_HotSwap
MX23: SwY; MX-1U-NoLED_HotSwap
MX24: SwH; MX-1U-NoLED_HotSwap
MX25: SwN; MX-1U-NoLED_HotSwap
MX26: SwRSHFT; MX-1U-NoLED_HotSwap
MX27: SwU; MX-1U-NoLED_HotSwap
MX28: SwJ; MX-1U-NoLED_HotSwap
MX29: SwM; MX-1U-NoLED_HotSwap
MX30: SwRMOD; MX-1U-NoLED_HotSwap
MX31: SwI; MX-1U-NoLED_HotSwap
MX32: SwK; MX-1U-NoLED_HotSwap
MX33: SwCOMMA; MX-1U-NoLED_HotSwap
MX34: SwRALT; MX-1U-NoLED_HotSwap
MX35: SwO; MX-1U-NoLED_HotSwap
MX36: SwL; MX-1U-NoLED_HotSwap
MX37: SwDOT; MX-1U-NoLED_HotSwap
MX38: SwMENU; MX-1U-NoLED_HotSwap
MX39: SwP; MX-1U-NoLED_HotSwap
MX40: SwCOLON; MX-1U-NoLED_HotSwap
MX41: Sw?; MX-1U-NoLED_HotSwap
MX42: SwBKSP; MX-1U-NoLED_HotSwap
MX43: SwENTER; MX-1U-NoLED_HotSwap
MX44: SwRCTRL; MX-1U-NoLED_HotSwap
MX45: SwGrave; MX-1U-NoLED_HotSwap
MX46: Sw1; MX-1U-NoLED_HotSwap
MX47: Sw2; MX-1U-NoLED_HotSwap
MX48: Sw3; MX-1U-NoLED_HotSwap
MX49: Sw4; MX-1U-NoLED_HotSwap
MX50: Sw5; MX-1U-NoLED_HotSwap
MX51: SwThL; MX-1U-NoLED_HotSwap
MX52: Sw6; MX-1U-NoLED_HotSwap
MX53: SwThR; MX-1U-NoLED_HotSwap
MX54: Sw7; MX-1U-NoLED_HotSwap
MX55: Sw8; MX-1U-NoLED_HotSwap
MX56: Sw9; MX-1U-NoLED_HotSwap
MX57: Sw0; MX-1U-NoLED_HotSwap
MX58: SwDEL; MX-1U-NoLED_HotSwap
R1, R2: 5.1K; R_0805_2012Metric
S1: BUTT-4; BUTT4; Manufacturer_Part_Number BUTT-4; Mouser Part Number 992-BUTT-4
SW2: SW_DIP_x01; 18252321
U1: ProMicro

Connections:
+BATT: J32.1, U1.24 (RAW)
COL0: JM20.1, JM33.4, U1.8 (C6)
COL1: JF45.1, JF45.4, JM20.2, JM33.3, U1.7 (D4)
COL2: JM20.3, JM33.2, MX10.1 (COL), MX38.1 (COL), U1.2 (RX)
COL3: JM20.4, JM33.1, MX14.1 (COL), MX34.1 (COL), U1.1 (TX)
COL4: JF5.4, JF43.1, MX15.1 (COL), MX16.1 (COL), MX17.1 (COL), MX27.1 (COL), MX28.1 (COL), MX29.1 (COL), MX49.1 (COL), MX54.1 (COL), U1.13 (B6)
COL5: JF5.1, JF43.4, MX19.1 (COL), MX20.1 (COL), MX21.1 (COL), MX23.1 (COL), MX24.1 (COL), MX25.1 (COL), MX50.1 (COL), MX52.1 (COL), U1.9 (D7)
GND: JF13.1, JF13.2, JF13.3, JF13.4, JF17.4, JM9.1, JM9.2, JM9.3, JM9.4, JM11.2, JM11.3, JM11.4, S1.B1, S1.D1, S1.G1, SW2.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
GND-TOP: J19.11, JM17.4
L1GND: H1.1, H2.1, JF9.1, JF9.2, JF9.3, JF9.4, JF11.2, JF11.3, JF11.4
L3GND: JM13.1, JM13.2, JM13.3, JM13.4
unnamed: D1.2 (A), JM21.1
unnamed: D2.2 (A), JM21.2
unnamed: D3.2 (A), JM21.3
unnamed: D4.2 (A), JM21.4
unnamed: D5.2 (A), JM22.1
unnamed: D6.2 (A), JM22.2
unnamed: D7.2 (A), JM22.3
unnamed: D8.2 (A), JM22.4
unnamed: D9.2 (A), JM23.4
unnamed: D10.2 (A), JM23.3
unnamed: D11.2 (A), JM23.2
unnamed: D12.2 (A), JM23.1
unnamed: D13.2 (A), MX14.2 (ROW)
unnamed: D14.2 (A), JM11.1, MX10.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), JF43.2
unnamed: D19.2 (A), JF43.3
unnamed: D20.2 (A), MX19.2 (ROW)
unnamed: D21.2 (A), MX20.2 (ROW)
unnamed: D22.2 (A), MX21.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX27.2 (ROW)
unnamed: D27.2 (A), MX28.2 (ROW)
unnamed: D28.2 (A), MX29.2 (ROW)
unnamed: D29.2 (A), JF5.2
unnamed: D30.2 (A), JF5.3
unnamed: D31.2 (A), JM30.4
unnamed: D32.2 (A), JM30.3
unnamed: D33.2 (A), JM30.2
unnamed: D34.2 (A), JM30.1
unnamed: D35.2 (A), JM29.4
unnamed: D36.2 (A), JM29.3
unnamed: D37.2 (A), JM29.2
unnamed: D38.2 (A), JM29.1
unnamed: D39.2 (A), JM28.4
unnamed: D40.2 (A), JM28.3
unnamed: D41.2 (A), JM28.2
unnamed: D42.2 (A), JM28.1
unnamed: D43.2 (A), MX34.2 (ROW)
unnamed: D44.2 (A), MX38.2 (ROW)
unnamed: D45.2 (A), JM3.4
unnamed: D46.2 (A), JM3.3
unnamed: D47.2 (A), JM3.2
unnamed: D48.2 (A), JM3.1
unnamed: D49.2 (A), MX49.2 (ROW)
unnamed: D50.2 (A), MX50.2 (ROW)
unnamed: D51.2 (A), JF45.3
unnamed: D52.2 (A), MX52.2 (ROW)
unnamed: D53.2 (A), JF45.2
unnamed: D54.2 (A), MX54.2 (ROW)
unnamed: D55.2 (A), JM31.4
unnamed: D56.2 (A), JM31.3
unnamed: D57.2 (A), JM31.2
unnamed: D58.2 (A), JM31.1
unnamed: J32.2, SW2.1
unnamed: JF3.1, MX45.2 (ROW)
unnamed: JF3.2, MX46.2 (ROW)
unnamed: JF3.3, MX47.2 (ROW)
unnamed: JF3.4, MX48.2 (ROW)
unnamed: JF20.1, MX1.1 (COL), MX2.1 (COL), MX3.1 (COL), MX45.1 (COL)
unnamed: JF20.2, MX4.1 (COL), MX5.1 (COL), MX6.1 (COL), MX46.1 (COL)
unnamed: JF20.3, MX7.1 (COL), MX8.1 (COL), MX9.1 (COL), MX47.1 (COL)
unnamed: JF20.4, MX11.1 (COL), MX12.1 (COL), MX13.1 (COL), MX48.1 (COL)
unnamed: JF21.1, MX11.2 (ROW)
unnamed: JF21.2, MX7.2 (ROW)
unnamed: JF21.3, MX4.2 (ROW)
unnamed: JF21.4, MX1.2 (ROW)
unnamed: JF22.1, MX12.2 (ROW)
unnamed: JF22.2, MX8.2 (ROW)
unnamed: JF22.3, MX5.2 (ROW)
unnamed: JF22.4, MX2.2 (ROW)
unnamed: JF23.1, MX3.2 (ROW)
unnamed: JF23.2, MX6.2 (ROW)
unnamed: JF23.3, MX9.2 (ROW)
unnamed: JF23.4, MX13.2 (ROW)
unnamed: JF28.1, MX44.2 (ROW)
unnamed: JF28.2, MX41.2 (ROW)
unnamed: JF28.3, MX37.2 (ROW)
unnamed: JF28.4, MX33.2 (ROW)
unnamed: JF29.1, MX43.2 (ROW)
unnamed: JF29.2, MX40.2 (ROW)
unnamed: JF29.3, MX36.2 (ROW)
unnamed: JF29.4, MX32.2 (ROW)
unnamed: JF30.1, MX42.2 (ROW)
unnamed: JF30.2, MX39.2 (ROW)
unnamed: JF30.3, MX35.2 (ROW)
unnamed: JF30.4, MX31.2 (ROW)
unnamed: JF31.1, MX58.2 (ROW)
unnamed: JF31.2, MX57.2 (ROW)
unnamed: JF31.3, MX56.2 (ROW)
unnamed: JF31.4, MX55.2 (ROW)
unnamed: JF33.1, MX31.1 (COL), MX32.1 (COL), MX33.1 (COL), MX55.1 (COL)
unnamed: JF33.2, MX35.1 (COL), MX36.1 (COL), MX37.1 (COL), MX56.1 (COL)
unnamed: JF33.3, MX39.1 (COL), MX40.1 (COL), MX41.1 (COL), MX57.1 (COL)
unnamed: JF33.4, MX42.1 (COL), MX43.1 (COL), MX44.1 (COL), MX58.1 (COL)
unnamed: JM5.1, MX26.1 (COL)
unnamed: JM5.2, MX26.2 (ROW)
unnamed: JM5.3, MX30.2 (ROW)
unnamed: JM5.4, MX30.1 (COL)
unnamed: JM43.1, MX18.1 (COL)
unnamed: JM43.2, MX18.2 (ROW)
unnamed: JM43.3, MX22.2 (ROW)
unnamed: JM43.4, MX22.1 (COL)
unnamed: JM45.1, MX53.1 (COL)
unnamed: JM45.2, MX53.2 (ROW)
unnamed: JM45.3, MX51.2 (ROW)
unnamed: JM45.4, MX51.1 (COL)
ROWL0: D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), U1.11 (B4)
ROWL1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D15.1 (K), D20.1 (K), U1.10 (E6)
ROWL2: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D16.1 (K), D21.1 (K), U1.12 (B5)
ROWL3: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D17.1 (K), D22.1 (K), U1.20 (F4)
ROWL4: D13.1 (K), D14.1 (K), D18.1 (K), D19.1 (K), D51.1 (K), U1.19 (F5)
ROWR0: D52.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), U1.18 (F6)
ROWR1: D23.1 (K), D26.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U1.17 (F7)
ROWR2: D24.1 (K), D27.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), U1.16 (B1)
ROWR3: D25.1 (K), D28.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U1.15 (B3)
ROWR4: D29.1 (K), D30.1 (K), D43.1 (K), D44.1 (K), D53.1 (K), U1.14 (B2)
RST: S1.A1, S1.C1, U1.22 (RST)
SCL: JF17.3, R1.1, U1.6 (SCL)
SCL-TOP: J19.9, JM17.3
SDA: JF17.2, R2.2, U1.5 (SDA)
SDA-TOP: J19.10, JM17.2
VCC: JF17.1, R1.2, R2.1, U1.21 (VCC)
VCC-TOP: J19.12, JM17.1

Notes on the sheet:
QMK: Matrix 6x10 (6 colum with 10 short rows, 5L and 5R) //TODO: Replace this #define MATRIX_ROW_PINS {D3,D2,D4,C6} #define MATRIX_COL_PINS {B2, B6, B5, B4,E6, D7, B3, F4, F5,F6, F7, B1} #define DIODE_DIRECTION COL2ROW
Proglide Cirque Touchpad Connector
These are two new thumb keys added in between the halves.

Board: 2 copper layers, 280.6 x 468.6 mm, 159 parts (80 on the bottom side), 139 nets.

## Commit log

2023-05-20 Initial schematics update: added number row, extra thumb key
2023-05-20 Replaced switch footprints, started laying out the PCBs
2023-05-20 Layed out switches and cross-plate connectors
2023-05-21 Rotated the wings into 44 degree position, added the external boundary
2023-05-21 Arranged the cross-board headers and sockets
2023-05-21 Routed L1 PCB
2023-05-23 Routed L2 PCB
2023-05-23 Added mounting holes, enlarged ProMicro pin holes to fit machined sockets.
2023-05-23 Fixed the thumbcluster connections.
2023-05-23 Fixed a missed connection.
2023-05-25 Added silkscreen
2023-05-25 Moved power switch to the positive line. Re-added silkscreens.
2023-05-25 Generated Gerbers.
2023-06-03 Corrected pin hole diameter, opened up the USB spot a bit.
2024-10-11 ThumbsUp v5: Corrected the ProMicro hole size.
2024-10-11 ThumbsUp v5: As prepared for re-order 20241011
2025-02-27 Added Pho:tos
2025-02-27 ThumbsUp v5: Updated description.
